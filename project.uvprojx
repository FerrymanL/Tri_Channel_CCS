# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, RT_USING_ARMLIBC, __RTTHREAD__, STM32F405xx, USE_HAL_DRIVER, __STDC_LIMIT_MACROS
  c include: rt-thread\components\drivers\smp_call;rt-thread\components\libc\compilers\common\extension;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\libcpu\arm\common;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\libc\posix\ipc;.;rt-thread\components\libc\posix\io\epoll;packages\stm32f4_hal_driver-latest\Inc\Legacy;rt-thread\components\net\utest;board;board\CubeMX_Config\Inc;rt-thread\components\drivers\include;rt-thread\components\drivers\include;libraries\HAL_Drivers\drivers\config;packages\stm32f4_cmsis_driver-latest\Include;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;packages\CMSIS-Core-latest\Include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;applications;rt-thread\components\drivers\phy;rt-thread\components\utilities\ulog;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\compilers\common\include;packages\stm32f4_hal_driver-latest\Inc;rt-thread\include;rt-thread\components\drivers\spi;libraries\HAL_Drivers\drivers;rt-thread\components\finsh;rt-thread\components\drivers\include;libraries\HAL_Drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: ad5541.c ws2812b.c main.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
    rt-thread/components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_spi.c drv_usart.c
    libraries/HAL_Drivers/: drv_common.c
  group Finsh
    rt-thread/components/finsh/: msh_parse.c cmd.c shell.c msh.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    rt-thread/src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_std.c rt_vsscanf.c
  group STM32F4-CMSIS
    packages/stm32f4_cmsis_driver-latest/Source/Templates/arm/: startup_stm32f405xx.s
    packages/stm32f4_cmsis_driver-latest/Source/Templates/: system_stm32f4xx.c
  group STM32F4-HAL
    packages/stm32f4_hal_driver-latest/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_crc.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cec.c stm32f4xx_hal_rng.c stm32f4xx_hal_cryp_ex.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
